Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Sanitary_Dispensers_Jofel_Soap-dispenser-Futura.ifc
Time: 2019-12-16T07:40:26
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2017-09-06
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFurnishingElement, Soap dispenser Futura
ePset_BIMobjectScript - Colour: AC53050 - Satin Stainless Steel; LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): Soap dispenser Futura; SKU (BO_prodsku): soap_dispenser_futura_0-85l_inox; ManufacturName (BO_Manufac): Jofel; BrandUrl (BO_brandurl): http://jofel.com; ProductFamily (BO_prodfam): Soap dispensers; ProductGroup (BO_prodgroup): Futura; ManufacturCountry (BO_mancont): Spain; DesignCountry (BO_designcont): Spain; EditionNumber (BO_edinum): 1; Width (BO_width): 127; Height (BO_height): 271; Depth (BO_depth): 110; Weight (BO_weight): 1.02; QR (BO_boqrurl): http://bimobject.com/jofel/product/soap_dispenser_futura_0-85l_inox; ProductDataUrl (BO_prodaturl): bimobject.com/jofel/product/soap_dispenser_futura_0-85l_inox; ProductUrl (BO_producturl): https://jofel.com/en/dosificador-de-jabon-futura.html; TechnicalDescription (BO_techcert): https://jofel.com/media/fichas/en/AC53050.pdf; MaterialMain (BO_mainmat): Stainless steel; MaterialSecondary (BO_secmat): ABS; BimObjectMainCategory (BO_bomaincat): Sanitary; BimObjectMainCategoryCode (BO_bomaincat_code): sanitary; BimObjectCategory (BO_bocat): Dispensers; BimObjectCategoryCode (BO_bocat_code): sanitary-dispensers; IfcClassification (BO_ifcclas): Furnishing Element; UnspcCode (BO_unspc): 30181505; Uniclass14Code (BO_uniclass_1_4_code): L8246; Uniclass14Description (BO_uniclass_1_4_desc): Soap holders/dispensers; Uniclass20Code (BO_uniclass_2_0_code): PR-35-76-80; Uniclass20Description (BO_uniclass_2_0_desc): Soap Dispensers; Uniclass2015Code (BO_uniclass2015_code): Pr_40_70_22_81; Uniclass2015Description (BO_uniclass2015_desc): Soap dispensers; NBSReference (BO_nbs_ref): 35-76-80; NBSReferenceDescription (BO_nbs_desc): Soap Dispensers; OmniClassCode (BO_omniclass_code): 23-31 25 29 13; OmniClassDescription (BO_omniclass_name): Hand Soap Dispensers; RegionEurope (BO_europe): AD, AL, AT, AX, BA, BE, BG, BY, CH, CY, CZ, DE, DK, EE, ES, FI, FO, FR, GB, GG, GI, GR, HR, HU, IE, IM, IS, IT, JE, LI, LT, LU, LV, MC, MD, ME, MK, MT, NL, NO, PL, PT, RO, RS, RU, SE, SI, SK, SM, UA, VA; RegionNorthAmerica (BO_northamerica): AG, AI, AW, BB, BL, BM, BQ, BS, BZ, CA, CR, CU, CW, DM, DO, GD, GP, GT, HN, HT, JM, KN, KY, LC, MF, MQ, MS, MX, NI, PA, PM, PR, SV, SX, TC, TT, US, VC, VG, VI; RegionSouthAmerica (BO_southamerica): AR, BO, BR, CL, CO, EC, FK, GF, GY, PE, PY, SR, UY, VE; RegionMiddleEast (BO_middleeast): AE, BH, EG, IL, IQ, IR, JO, KW, LB, OM, PS, QA, SA, TR, YE; RegionAsia (BO_asia): AM, AZ, BD, BN, BT, CC, CN, CX, GE, HK, ID, IN, IO, JP, KG, KH, KP, KR, KZ, LA, LK, MM, MN, MO, MV, MY, NP, PH, PK, SG, TH, TJ, TM, TW, UZ, VN; RegionOceania (BO_oceania): AS, AU, CK, FJ, FM, GU, KI, MH, MP, NC, NF, NR, NU, NZ, PF, PG, PN, PW, SB, TK, TL, TO, TV, UM, WF, WS, VU; RegionAfrica (BO_africa): AO, BF, BI, BJ, BW, CD, CF, CG, CI, CM, CV, DJ, DZ, EH, ER, ET, GA, GH, GM, GN, GQ, GW, KE, KM, LR, LS, LY, MA, MG, ML, MR, MU, MW, MZ, NA, NE, NG, RE, RW, SC, SD, SH, SL, SN, SO, SS, ST, SZ, TD, TG, TN, TZ, UG, YT, ZA, ZM, ZW
